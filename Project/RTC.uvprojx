# Keil uVision project RTC.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RTC +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\Common;..\Main;..\Startup_config;..\STM32F4xx_HAL_Driver\inc;..\USER\LED;..\USER\LCD;..\USER\KEY;..\USER\LCD;..\USER\RTC;..\USER\UASRT;..\USER\Alarm;..\USER\beep;..\USER\DHT11
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../Main/: main.c stm32f4xx_it.c
  group Startup_config
    ../Startup_config/: system_stm32f4xx.c stm32f4xx_hal_msp.c startup_stm32f407xx.s cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm4.h mpu_armv7.h
  group USER
    ../USER/LED/: led.c
    ../USER/KEY/: key.c
    ../USER/LCD/: lcd.c
    ../USER/RTC/: rtc.c
    ../USER/UASRT/: usart1.c usart1.h usart2.c usart2.h usart.c usart.h
    ../USER/Alarm/: Alarm.c Alarm.h
    ../USER/beep/: Beep.c Beep.h
    ../USER/DHT11/: DHT11.c DHT11.h
  group STM32F4_HAL_FWLIB
    ../STM32F4xx_HAL_Driver/src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_uart.c
  group Common
    ../Common/: common.c
software components: CMSIS:CORE 4.3.0
